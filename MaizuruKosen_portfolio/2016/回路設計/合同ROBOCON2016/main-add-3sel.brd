# Repository asaponhi/HirroPi_Portfolio

## EAGLE design MaizuruKosen_portfolio/2016/回路設計/合同ROBOCON2016/main-add-3sel.brd

Parts:
C1, C2: CAPACITOR-330U; C_330U
C3, C4: MLCC-3; MLCC_50
C5, C6, C7: MLCC-2; MLCC_25
C8, C9: 331; MLCC_50
D1: DIODE_3
D2, D3: DIODE_4
IC1: MEGA88; DIL28-3
IC2: 78; 78XX
JP1: PINHD-1X2"; 1*02
JP2, JP3: PINHD-1X2; 1X02
JP4: PINHD-2X6; 2X06
JP5, JP6, JP7, JP10, JP11, JP12, JP16, JP17: PINHD-1X1; 1X01
LED2, LED3, LED4: LED5MM
LEDBATTERY: LED5MM
MD1, MD2, MD3, MD4: MOTADORA2011; MOTADORA2010
PHOTOINTARAPUTA: PINHD-SENSOR; 1*03(KIKAKU)
Q1: CTYSTALHC49/S; HC49/S
Q2, Q3: N-FET; TO-220V
R1, R3: RESISTORS-3; R_0.3
R4, R7: 400; R_0.3
R5: 500; R_0.3
R6, R9: 1k; R_0.3
R8: 500=>220; R_0.3
RORIKON: PINHD-SENSOR; 1*03(KIKAKU)
SW1: TOGGLE; 9450-2
U$23, U$29: TLP251; DIP8

Connections:
+5V: C2.P$1 (1), C4.1, C7.1, D1.A, IC1.7 (VCC), IC1.20 (AVCC), IC1.21 (AREF), IC2.P$3 (OUT), JP4.1, JP4.2, JP4.3, JP4.4, MD1.5V, MD2.5V, MD3.5V, MD4.5V, PHOTOINTARAPUTA.VCC, R1.2; also elsewhere on the board
+12V: C8.1, C9.2, D2.C, D3.C, JP2.2, JP3.2, MD1.12V, MD2.12V, MD3.12V, MD4.12V, U$23.8, U$29.8
+24V: MD1.18V, MD2.18V, MD3.18V, MD4.18V
GND: C1.P$2 (2), C2.P$2 (2), C3.2, C4.2, C5.1, C6.1, C7.2, IC1.8 (GND), IC1.22 (AGND), IC2.P$2 (GND), JP1.2, JP4.9, JP4.10, JP4.11, JP4.12, LED2.K (C), LED3.K (C), LED4.K (C), LEDBATTERY.K (C), MD1.GND, MD2.GND, MD3.GND, MD4.GND, PHOTOINTARAPUTA.GND, RORIKON.GND, U$23.3, U$29.3; also elsewhere on the board
GND12: C8.2, C9.1, MD1.MGND, MD2.MGND, MD3.MGND, MD4.MGND, Q2.3 (S), Q3.3 (S), U$23.5, U$29.5
unnamed: C5.2, IC1.9 (PB6(XTAL1/TOSC1)), Q1.2
unnamed: C6.2, IC1.10 (PB7(XTAL2/TOSC2)), Q1.1
unnamed: JP1.1, SW1.1 (O)
unnamed: C1.P$1 (1), C3.1, D1.C, IC2.P$1 (IN), SW1.2
unnamed 9: IC1.27 ((SDA/ADC4)PC4), PHOTOINTARAPUTA.SIG; also elsewhere on the board
unnamed: IC1.23 ((ADC0)PC0), R7.1, R9.1
unnamed: IC1.24 ((ADC1)PC1), R4.1, R6.1
unnamed: IC1.2 ((RXD)PD0), JP4.5, JP4.6
unnamed: IC1.18 ((MISO)PB4), MD4.A
unnamed: IC1.6 ((XCK/T0)PD4), MD1.B
unnamed: IC1.4 ((INT0)PD2), MD1.A
unnamed: IC1.19 ((SCK)PB5), MD4.B
unnamed: IC1.3 ((TXD)PD1), JP4.7, JP4.8
unnamed: IC1.28 ((SCL/ADC5)PC5), R3.1
unnamed: IC1.5 ((OC2B/INT1)PD3), MD1.PWM
unnamed: IC1.17 ((OC2A/MOSI)PB3), MD4.PWM
unnamed: IC1.16 ((OC1B/SS)PB2), MD3.A
unnamed: IC1.15 ((OC1A)PB1), MD3.PWM
unnamed: IC1.14 ((CLKO/ICP1)PB0), MD3.B
unnamed: IC1.13 ((AIN1)PD7), MD2.B
unnamed: IC1.12 ((OC0A/AIN0)PD6), MD2.PWM
unnamed: IC1.11 ((OC0B/T1)PD5), MD2.A
unnamed: JP12.1, MD3.B-OUT
unnamed: JP6.1, MD3.A-OUT
unnamed: JP11.1, MD2.A-OUT
unnamed: JP7.1, MD1.B-OUT
unnamed: JP10.1, MD1.A-OUT
unnamed: D3.A, JP2.1, Q3.2 (D)
unnamed: Q2.1 (G), R5.2
unnamed: JP5.1, MD2.B-OUT
unnamed: JP16.1, MD4.B-OUT
unnamed: JP17.1, MD4.A-OUT
unnamed: D2.A, JP3.1, Q2.2 (D)
unnamed: R4.2, U$23.2
unnamed: R5.1, U$23.6
unnamed: LED3.A, R6.2
unnamed: LEDBATTERY.A, R1.1
unnamed: Q3.1 (G), R8.2
unnamed 43: IC1.25 ((ADC2)PC2), RORIKON.VCC; also elsewhere on the board
unnamed: R7.2, U$29.2
unnamed: R8.1, U$29.6
unnamed: LED4.A, R9.2
unnamed 47: IC1.26 ((ADC3)PC3), RORIKON.SIG; also elsewhere on the board
unnamed: LED2.A, R3.2

Parts:
C1, C2: CAPACITOR-330U; C_330U
C3, C4: MLCC-3; MLCC_50
C5, C6, C7: MLCC-2; MLCC_25
C8, C9: 331; MLCC_50
D1: DIODE_3
D2, D3: DIODE_4
IC1: MEGA88; DIL28-3
IC2: 78; 78XX
JP1: PINHD-1X2"; 1*02
JP2, JP3: PINHD-1X2; 1X02
JP4: PINHD-2X6; 2X06
JP5, JP6, JP7, JP10, JP11, JP12, JP16, JP17: PINHD-1X1; 1X01
LED2, LED3, LED4: LED5MM
LEDBATTERY: LED5MM
MD1, MD2, MD3, MD4: MOTADORA2011; MOTADORA2010
Q1: CTYSTALHC49/S; HC49/S
Q2, Q3: N-FET; TO-220V
R1, R3: RESISTORS-3; R_0.3
R4, R7: 400; R_0.3
R5: 500; R_0.3
R6, R9: 1k; R_0.3
R8: 500=>220; R_0.3
SW1: TOGGLE; 9450-2
U$23, U$29: TLP251; DIP8
U$34, U$36: PINHD-SENSOR; 1*03(KIKAKU)

Connections:
+5V: C2.P$1 (1), C4.1, C7.1, D1.A, IC1.7 (VCC), IC1.20 (AVCC), IC1.21 (AREF), IC2.P$3 (OUT), JP4.1, JP4.2, JP4.3, JP4.4, MD1.5V, MD2.5V, MD3.5V, MD4.5V, R1.2, U$36.VCC; also elsewhere on the board
+12V: C8.1, C9.2, D2.C, D3.C, JP2.2, JP3.2, MD1.12V, MD2.12V, MD3.12V, MD4.12V, U$23.8, U$29.8
+24V: MD1.18V, MD2.18V, MD3.18V, MD4.18V
GND: C1.P$2 (2), C2.P$2 (2), C3.2, C4.2, C5.1, C6.1, C7.2, IC1.8 (GND), IC1.22 (AGND), IC2.P$2 (GND), JP1.2, JP4.9, JP4.10, JP4.11, JP4.12, LED2.K (C), LED3.K (C), LED4.K (C), LEDBATTERY.K (C), MD1.GND, MD2.GND, MD3.GND, MD4.GND, U$23.3, U$29.3, U$34.GND, U$36.GND; also elsewhere on the board
GND12: C8.2, C9.1, MD1.MGND, MD2.MGND, MD3.MGND, MD4.MGND, Q2.3 (S), Q3.3 (S), U$23.5, U$29.5
unnamed: C5.2, IC1.9 (PB6(XTAL1/TOSC1)), Q1.2
unnamed: C6.2, IC1.10 (PB7(XTAL2/TOSC2)), Q1.1
unnamed: JP1.1, SW1.1 (O)
unnamed: C1.P$1 (1), C3.1, D1.C, IC2.P$1 (IN), SW1.2
unnamed 9: IC1.27 ((SDA/ADC4)PC4), U$36.SIG; also elsewhere on the board
unnamed: IC1.23 ((ADC0)PC0), R7.1, R9.1
unnamed: IC1.24 ((ADC1)PC1), R4.1, R6.1
unnamed: IC1.2 ((RXD)PD0), JP4.5, JP4.6
unnamed: IC1.18 ((MISO)PB4), MD4.A
unnamed: IC1.6 ((XCK/T0)PD4), MD1.B
unnamed: IC1.4 ((INT0)PD2), MD1.A
unnamed: IC1.19 ((SCK)PB5), MD4.B
unnamed: IC1.3 ((TXD)PD1), JP4.7, JP4.8
unnamed: IC1.28 ((SCL/ADC5)PC5), R3.1
unnamed: IC1.5 ((OC2B/INT1)PD3), MD1.PWM
unnamed: IC1.17 ((OC2A/MOSI)PB3), MD4.PWM
unnamed: IC1.16 ((OC1B/SS)PB2), MD3.A
unnamed: IC1.15 ((OC1A)PB1), MD3.PWM
unnamed: IC1.14 ((CLKO/ICP1)PB0), MD3.B
unnamed: IC1.13 ((AIN1)PD7), MD2.B
unnamed: IC1.12 ((OC0A/AIN0)PD6), MD2.PWM
unnamed: IC1.11 ((OC0B/T1)PD5), MD2.A
unnamed: JP12.1, MD3.B-OUT
unnamed: JP6.1, MD3.A-OUT
unnamed: JP11.1, MD2.A-OUT
unnamed: JP7.1, MD1.B-OUT
unnamed: JP10.1, MD1.A-OUT
unnamed: D3.A, JP2.1, Q3.2 (D)
unnamed: Q2.1 (G), R5.2
unnamed: JP5.1, MD2.B-OUT
unnamed: JP16.1, MD4.B-OUT
unnamed: JP17.1, MD4.A-OUT
unnamed: D2.A, JP3.1, Q2.2 (D)
unnamed: R4.2, U$23.2
unnamed: R5.1, U$23.6
unnamed: LED3.A, R6.2
unnamed: LEDBATTERY.A, R1.1
unnamed: Q3.1 (G), R8.2
unnamed 43: IC1.25 ((ADC2)PC2), U$34.VCC; also elsewhere on the board
unnamed: R7.2, U$29.2
unnamed: R8.1, U$29.6
unnamed: LED4.A, R9.2
unnamed 47: IC1.26 ((ADC3)PC3), U$34.SIG; also elsewhere on the board
unnamed: LED2.A, R3.2

Board: 2 copper layers, 124.5 x 73.7 mm, 50 parts (2 on the bottom side), 49 nets.

## EAGLE design MaizuruKosen_portfolio/2017/回路設計/Gourobo2017/Decoletion/MAINfin2.brd

Parts:
C1, C2: 104; MLCC_25
JP1, JP2: PINHD-1X2"; 1*02
U$1, U$8: WS2822S
U$4, U$10: 10k; R_0.3
U$5, U$6, U$7, U$11, U$12: 75; R_0.3

Connections:
+5V: JP1.1, U$1.6 (6VDD), U$6.2, U$8.6 (6VDD), U$12.2
ADR1: JP2.2, U$5.1, U$7.2, U$11.1
DATA: JP2.1, U$4.1, U$10.1
GND: C1.2, C2.2, JP1.2, U$1.4 (4GND), U$8.4 (4GND)
unnamed: C1.1, U$1.3 (3VCC), U$6.1
unnamed: U$1.5 (5ADRO), U$7.1
unnamed: U$1.1 (1DAI), U$4.2
unnamed: U$1.2 (2ADRI), U$5.2
unnamed: U$8.1 (1DAI), U$10.2
unnamed: U$8.2 (2ADRI), U$11.2
unnamed: C2.1, U$8.3 (3VCC), U$12.1

Board: 2 copper layers, 43.2 x 23.8 mm, 13 parts (2 on the bottom side), 11 nets.

## EAGLE design MaizuruKosen_portfolio/2017/回路設計/Gourobo2017/MyCreate_MorterDriver/asadora/mtD-Relay1C(ACTP112)fotCo2.brd

Parts:
C1: 0.1; MLCC_25
C2: 0.1uF; MLCC_25
D1, D2, D3, D4, D6: DIODE_JISSO2
IC1: TIYN2313; DIL20
JP1, JP8: PINHD-2X6; 2X06
JP4: PINHD-1X3; 1X03
JP6, JP7: PINHD-1X24; 1X24
LED-A: LED3MM
LED-B: LED3MM
OK1, OK3: TLP621; DIP4
Q1: SKI03036
R2: 330< <500(10mA); 3216
R3, R4: 330; R_0.3
R3(ダンパ抵抗）: 10~20or47~100; 1608
R4(部リーダ抵抗）: 10~20kor1k; 1608
R6, R8: 470; 3216
R11, R12: 5.6K; R_0.3
TR1, TR2: 1815I; TO92A
U$3, U$15: OUTPIN-PV-3
U$4: TLP251; DIP8

Connections:
+5V: C2.1, IC1.20 (VCC), JP6.24, JP7.24
+12V: OK1.4 (COL), OK3.4 (COL)
A-SIG: IC1.14 ((OC0A/PCINT2)PB2), JP4.3, LED-A.A
B-SIG: IC1.17 ((MOSI/DI/SDA/PCINT5)PB5), JP4.1, LED-B.A
FON: IC1.9 ((OC0B/T1)PD5), R2.P$5 (1)
GND: C2.2, IC1.10 (GND), JP6.23, JP7.23, OK1.2 (C), OK3.2 (C), R6.P$6 (2), R8.P$6 (2), U$4.1, U$4.3, U$4.4
unnamed: R11.2, TR1.B
unnamed: C1.1, D1.P$2 (C), D2.P$2 (C), D3.P$2 (C), D6.P$2 (C), JP1.2, JP1.4, JP1.6, JP1.8, JP1.10, JP1.12, JP6.15, JP6.16, JP6.17, JP6.18, JP6.19, JP7.15, JP7.16, JP7.17, JP7.18, JP7.19, JP8.2, JP8.4, JP8.6, JP8.8, JP8.10, JP8.12, U$4.8
unnamed: R12.2, TR2.B
unnamed: R3(ダンパ抵抗）.P$1 (1), U$4.6
unnamed: Q1.G, R3(ダンパ抵抗）.P$2 (2), R4(部リーダ抵抗）.P$1 (1)
unnamed: D4.P$2 (C), JP1.3, JP1.5, JP8.3, JP8.5, Q1.D
unnamed: R2.P$6 (2), U$4.2
unnamed: LED-B.K (C), R6.P$5 (1)
unnamed: LED-A.K (C), R8.P$5 (1)
unnamed: OK1.1 (A), R3.2
unnamed: D6.P$1 (A), JP8.1, TR2.C
unnamed: OK1.3 (EMIT), R11.1
unnamed: D3.P$1 (A), JP8.7, JP8.9, JP8.11, U$15.OUT
unnamed: OK3.1 (A), R4.2
unnamed: C1.2, D4.P$1 (A), JP6.1, JP6.2, JP6.3, JP6.4, JP6.5, JP6.6, JP6.7, JP6.8, JP6.9, JP6.10, JP6.11, JP6.12, JP6.13, JP6.14, JP6.20, JP6.21, JP6.22, JP7.1, JP7.2, JP7.3, JP7.4, JP7.5, JP7.6, JP7.7, JP7.8, JP7.9, JP7.10, JP7.11, JP7.12, JP7.13, JP7.14, JP7.20, JP7.21, JP7.22, Q1.S, R4(部リーダ抵抗）.P$2 (2), TR1.E, TR2.E, U$4.5
unnamed: OK3.3 (EMIT), R12.1
unnamed: D2.P$1 (A), JP1.7, JP1.9, JP1.11, U$3.OUT
P-SIG: IC1.16 ((OC1B/PCINT4)PB4), JP4.2
R1-3: D1.P$1 (A), JP1.1, TR1.C
RE1: R3.1
RE2: IC1.18 ((MISO/DO/PCINT6)PB6), R4.1

Notes on the sheet:
TINY2313
PINHEAD
TLP250
ACTP112
2*6pinはタワー型にするため（リレーを寝かした） ピンの足の長さは10mm 15mmのタイプを使えば、リレーを寝かさずともよい（回路に直接さす） 上の基盤と干渉せず、回路の大きさも2/3倍にできた

Board: 2 copper layers, 56.8 x 72.9 mm, 32 parts (17 on the bottom side), 26 nets.

## EAGLE design MaizuruKosen_portfolio/2017/回路設計/Gourobo2017/MyCreate_MorterDriver/relay-testbord/comp/mtD-Relay-TBisp2.brd

Parts:
C1, C2: CAPACITOR-330U; C_330U
C3, C4, C8: MLCC-3; MLCC_50
C5, C6: MLCC-2; MLCC_25
D1: DIODE_3
IC1: MEGA88; DIL28-3
IC2: 78; 78XX
JP1, JP6, JP7, JP8: PINHD-1X24; 1X24
JP2, JP4: PINHD-1X3-1; 1*03
JP3, JP5: PINHD-1X1; 1X01
LEDBATTERY: LED5MM
LEDBATTERY4: LED3MM
Q1: CTYSTALHC49/S; HC49/S
R1: RESISTORS-3; R_0.3
R4, R5: RESISTORS3216; 3216
SDFS: LED3MM
SW1, SW2: TOGGLE; 9450-2
SW9, SW10, SW11: TACT; 1273
U$22: ISP; 2X03

Connections:
+5V: C2.P$1 (1), C4.1, C8.1, D1.A, IC1.7 (VCC), IC1.20 (AVCC), IC1.21 (AREF), IC2.P$3 (OUT), JP2.3 (1), JP3.1, JP6.24, JP7.24, R1.2, SW1.1 (O), U$22.2 (VCC)
A-SIG: IC1.6 ((XCK/T0)PD4), JP4.1 (3)
B-SIG: IC1.2 ((RXD)PD0), JP4.3 (1)
GND: JP6.23, JP7.23, R4.P$5 (1), R5.P$5 (1), U$22.6 (GND)
GND12: JP6.20, JP6.21, JP6.22, JP7.20, JP7.21, JP7.22
unnamed: C5.2, IC1.9 (PB6(XTAL1/TOSC1)), Q1.2
unnamed: C6.2, IC1.10 (PB7(XTAL2/TOSC2)), Q1.1
unnamed: JP6.15, JP6.16, JP6.17, JP6.18, JP6.19, JP7.15, JP7.16, JP7.17, JP7.18, JP7.19
unnamed: IC1.23 ((ADC0)PC0), JP2.1 (3)
unnamed: C1.P$1 (1), C3.1, D1.C, IC2.P$1 (IN), SW1.2
unnamed: IC1.1 (PC6(/RESET)), U$22.5 (RESET)
unnamed: IC1.16 ((OC1B/SS)PB2), SDFS.A
unnamed: R4.P$6 (2), SDFS.K (C)
unnamed: IC1.18 ((MISO)PB4), U$22.1 (MISO)
unnamed: LEDBATTERY4.K (C), R5.P$6 (2)
unnamed: C1.P$2 (2), C2.P$2 (2), C3.2, C4.2, C5.1, C6.1, C8.2, IC1.8 (GND), IC1.22 (AGND), IC2.P$2 (GND), JP2.2, JP5.1, LEDBATTERY.K (C), SW2.2, SW9.3 (S), SW9.4 (S1), SW10.3 (S), SW10.4 (S1), SW11.3 (S), SW11.4 (S1)
unnamed: IC1.19 ((SCK)PB5), U$22.3 (SCK)
unnamed: IC1.26 ((ADC3)PC3), LEDBATTERY4.A
unnamed: LEDBATTERY.A, R1.1
unnamed: JP6.1, JP6.2, JP6.3, JP6.4, JP6.5, JP6.6, JP6.7, JP6.8, JP6.9, JP6.10, JP6.11, JP6.12, JP6.13, JP6.14, JP7.1, JP7.2, JP7.3, JP7.4, JP7.5, JP7.6, JP7.7, JP7.8, JP7.9, JP7.10, JP7.11, JP7.12, JP7.13, JP7.14
P-SIG: IC1.5 ((OC2B/INT1)PD3), JP4.2
SW2: IC1.28 ((SCL/ADC5)PC5), SW2.3 (S)
SW9: IC1.15 ((OC1A)PB1), SW9.1, SW9.2 (P1)
SW10: IC1.17 ((OC2A/MOSI)PB3), SW10.1, SW10.2 (P1), U$22.4 (MOSI)
SW11: IC1.27 ((SDA/ADC4)PC4), SW11.1, SW11.2 (P1)

Board: 2 copper layers, 99.0 x 83.5 mm, 31 parts (4 on the bottom side), 25 nets.

## EAGLE design MaizuruKosen_portfolio/2017/回路設計/Gourobo2017/NewEncoderver/ASA/comp/main04kai.brd

Parts:
C1: MLCC-2; MLCC_25
JP1, JP2: PINHD-13_90°; 1*3_90
U$1: 74LVC2G17
U$2: PINHD14_90°; 1*4_90

Connections:
+5V: C1.1, JP1.2, JP2.2, U$1.5, U$2.3
GND: C1.2, JP1.3, JP2.3, U$1.2, U$2.4
unnamed: U$1.6, U$2.2
unnamed: U$1.4, U$2.1
unnamed: JP1.1, U$1.1
unnamed: JP2.1, U$1.3

Board: 2 copper layers, 36.0 x 19.4 mm, 5 parts (1 on the bottom side), 6 nets.
