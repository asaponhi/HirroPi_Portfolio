# Repository asaponhi/HirroPi_Portfolio

## EAGLE design MaizuruKosen_portfolio/2017/回路設計/Gourobo2017/main_curcuit/asaMain/sensor/sencerMain2.brd

Parts:
JP3: PINHD-2X7; 2X07
JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP19, JP20, JP21: PINHD-1X3-1; 1*03

Connections:
+5V: JP3.7, JP10.2, JP11.2, JP12.2, JP13.2, JP14.2, JP15.2, JP16.2, JP17.2, JP18.2, JP19.2, JP20.2, JP21.2
FOT1: JP3.10, JP10.1 (3)
FOT2: JP3.8, JP11.1 (3)
FOT3: JP3.6, JP12.1 (3)
FOT4: JP3.4, JP13.1 (3)
GND: JP3.12, JP10.3 (1), JP11.3 (1), JP13.3 (1), JP14.3 (1), JP15.3 (1), JP17.3 (1), JP18.3 (1), JP19.3 (1), JP21.3 (1)
unnamed: JP12.3 (1), JP16.3 (1), JP20.3 (1)
RIMIT1: JP3.2, JP14.1 (3)
RIMIT2: JP3.1, JP15.1 (3)
RIMIT3: JP3.3, JP16.1 (3)
RIMIT4: JP3.5, JP17.1 (3)
RIMIT5: JP3.9, JP18.1 (3)
RIMIT6: JP3.11, JP19.1 (3)
RIMIT7: JP3.13, JP20.1 (3)
RIMIT8: JP3.14, JP21.1 (3)

Board: 2 copper layers, 50.8 x 155.9 mm, 13 parts (0 on the bottom side), 15 nets.

## EAGLE design MaizuruKosen_portfolio/2017/回路設計/Ultrasonic2017/UltraCircuit/Ver6/Ultrafin(43)v6_fin.brd

Parts:
555C1: 390pf; 1608
555RA1: ３6ｋ; R_0.3
AUC1: 0.01uf; 1608
AUC2: 1uf; 1608
AUL: 1k; 3225
AUR: 1k; 3225
AUR1: 36; R_0.3
AUR2: 36(27 47); 1608
BC1: 390pf; MLCC_50
BC2: 390pf; 1608
C1: 47uf; C_1U
C2, C3, C4, C8, C17: 0.1uf; 1608
C10, C12: 3.3uf; MLCC_50
D4: DIODE_JISSO2
DIVR1, DIVR2: 15k; R_0.3
DP1, DP2: DIODE_3
GC1: 0.1uf; 1608
GC2: 20pf; 1608
GR1: 1k; 3225
GR2: 3.3k; R_0.3
J1: MJ-352W-C; MJ-352-M-C
JP1, JP2: PINHD-1X2"; 1*02
L1: 68mH; LHL10NB104J
LEDBATTERY: LED3MM
N1: 20; 1608
N2: 20; R_0.3
N3, N4: 270; 1608
P11, P21: 270; R_0.3
P12, P22: 3.3k; R_0.3
Q1: FDS4935A
R1: RESISTORS3216; 3216
U$3: 3296W; R_VARIABLE
U$4, U$8, U$10, U$11, U$12, U$18, U$23, U$25, U$27, U$28, U$31, U$39, U$40, U$42, U$45, U$46, U$47, U$48, U$49, U$50, U$51, U$52, U$53, U$54, U$55, U$56, U$57, U$58, U$59, U$60, U$61, U$62, U$63, U$64, U$71, U$74, U$78, U$79, U$80, U$81, U$82, U$83: UT1007-Z325R
U$5: ICM7555CD; SOP8
U$14: 74HC04NS; SOP14
U$16: BF2904F; SOP8
U$29: UPA2753GR
U$35, U$36: 2SA1162
U$37, U$38: 2SC2712
U$67: BA17805FP
U$84: SLIDE_ESD175202

Connections:
+5V: C1.P$1 (1), C2.P$1 (1), C3.P$1 (1), C8.P$1 (1), C17.P$1 (1), D4.P$1 (A), DIVR1.2, R1.P$6 (2), U$5.4 (RES), U$5.8 (V+), U$16.8 (V+), U$37.C, U$38.C, U$67.OUTPUT (OUT)
+12V: C4.P$1 (1), DP1.C, DP2.C, JP1.1, JP2.1, P11.2, P21.2, Q1.1 (S2), Q1.3 (S1), U$84.A
AGND: 555C1.P$2 (2), AUC1.P$2 (2), AUR1.1, AUR2.P$1 (1), C1.P$2 (2), C8.P$2 (2), C17.P$2 (2), DIVR2.1, GC1.P$2 (2), J1.1, JP1.2, JP2.2, LEDBATTERY.K (C), P12.1, P22.1, U$5.1 (GND), U$14.1 (1A), U$14.3 (2A), U$14.5 (3A), U$14.7 (GND), U$14.9 (4A), U$16.3 (IN1+), U$16.4 (GND), U$29.1 (S1), U$29.3 (S2), U$35.C, U$36.C, U$67.COMMON (GND)
GND: C3.P$2 (2), C4.P$2 (2)
unnamed: AUR.P$1 (1), AUR2.P$2 (2), J1.2, J1.3
unnamed: AUL.P$1 (1), AUR1.2, J1.4, J1.5
unnamed: AUC1.P$1 (1), AUC2.P$1 (1), AUL.P$2 (2), AUR.P$2 (2)
unnamed: C12.1, N2.1, U$36.E, U$38.E
unnamed: BC2.P$1 (1), N4.P$1 (1), U$14.11 (5A), U$14.12 (6Y)
unnamed: Q1.7 (D22), Q1.8 (D21), U$4.2 (-), U$8.2 (-), U$10.2 (-), U$11.2 (-), U$12.2 (-), U$18.2 (-), U$23.2 (-), U$25.2 (-), U$27.2 (-), U$28.2 (-), U$29.7 (D12), U$29.8 (D11), U$31.2 (-), U$39.2 (-), U$40.2 (-), U$42.2 (-), U$45.2 (-), U$46.2 (-), U$47.2 (-), U$48.2 (-), U$49.2 (-), U$50.2 (-), U$51.2 (-), U$52.2 (-), U$53.2 (-), U$54.2 (-), U$55.2 (-), U$56.2 (-), U$57.2 (-), U$58.2 (-), U$59.2 (-), U$60.2 (-), U$61.2 (-), U$62.2 (-), U$63.2 (-), U$64.2 (-), U$71.2 (-), U$74.2 (-), U$78.2 (-), U$79.2 (-), U$80.2 (-), U$81.2 (-), U$82.2 (-), U$83.2 (-)
unnamed: 555C1.P$1 (1), 555RA1.2, U$5.2 (TRI), U$5.6 (THR)
unnamed: U$3.2, U$5.3 (OUT), U$14.13 (6A)
unnamed: 555RA1.1, U$3.1
unnamed: L1.1, Q1.5 (D12), Q1.6 (D11), U$29.5 (D22), U$29.6 (D21)
unnamed: C10.1, N1.P$1 (1), U$35.E, U$37.E
unnamed: C10.2, DP1.A, P11.1, P12.2, Q1.2 (G2)
unnamed: BC1.2, N3.P$2 (2), U$35.B, U$37.B
unnamed: BC2.P$2 (2), N4.P$2 (2), U$36.B, U$38.B
unnamed: BC1.1, N3.P$1 (1), U$14.10 (5Y)
unnamed: N1.P$2 (2), U$29.2 (G1)
unnamed: AUC2.P$2 (2), DIVR1.1, DIVR2.2, U$16.5 (IN2+)
unnamed: GC2.P$1 (1), GR1.P$2 (2), GR2.2, U$16.6 (IN2-)
unnamed: GC1.P$1 (1), GR1.P$1 (1)
unnamed: C12.2, DP2.A, P21.1, P22.2, Q1.4 (G1)
unnamed: N2.2, U$29.4 (G2)
unnamed: D4.P$2 (C), U$67.INPUT (IN), U$84.C
unnamed: U$16.1 (OUT1), U$16.2 (IN1-)
unnamed: GC2.P$2 (2), GR2.1, U$5.5 (CON), U$16.7 (OUT2)
unnamed: LEDBATTERY.A, R1.P$5 (1)
unnamed: L1.2, U$4.1 (+), U$8.1 (+), U$10.1 (+), U$11.1 (+), U$12.1 (+), U$18.1 (+), U$23.1 (+), U$25.1 (+), U$27.1 (+), U$28.1 (+), U$31.1 (+), U$39.1 (+), U$40.1 (+), U$42.1 (+), U$45.1 (+), U$46.1 (+), U$47.1 (+), U$48.1 (+), U$49.1 (+), U$50.1 (+), U$51.1 (+), U$52.1 (+), U$53.1 (+), U$54.1 (+), U$55.1 (+), U$56.1 (+), U$57.1 (+), U$58.1 (+), U$59.1 (+), U$60.1 (+), U$61.1 (+), U$62.1 (+), U$63.1 (+), U$64.1 (+), U$71.1 (+), U$74.1 (+), U$78.1 (+), U$79.1 (+), U$80.1 (+), U$81.1 (+), U$82.1 (+), U$83.1 (+)
unnamed: C2.P$2 (2), U$14.14 (V+)

Notes on the sheet:
保護ダイオード 出力側のコンデンサ容量が 大きいときはつけよう
f=1/(1.4*RC*C) RC=46kΩ C=0.000390uf f=40kHz

Board: 2 copper layers, 117.2 x 57.4 mm, 95 parts (34 on the bottom side), 31 nets.
