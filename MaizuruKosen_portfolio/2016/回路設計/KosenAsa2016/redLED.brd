# Repository asaponhi/HirroPi_Portfolio (continued)

## EAGLE design MaizuruKosen_portfolio/2017/回路設計/Ultrasonic2017/UltraCircuit/Ver6/Ultrafin(43)v6_finfix.brd

Parts:
555C1: 390pf; 1608
555RA1: ３6ｋ; R_0.3
AUC1: 0.01uf; 1608
AUC2: 1uf; 1608
AUL: 1k; 3225
AUR: 1k; 3225
AUR1: 36; R_0.3
AUR2: 36(27 47); 1608
BC1: 390pf; MLCC_50
BC2: 390pf; 1608
C1: 47uf; C_1U
C2, C3, C4, C8, C17: 0.1uf; 1608
C10, C12: 3.3uf; MLCC_50
D4: DIODE_JISSO2
DIVR1, DIVR2: 15k; R_0.3
DP1, DP2: DIODE_3
GC1: 0.1uf; 1608
GC2: 20pf; 1608
GR1: 1k; 3225
GR2: 3.3k; R_0.3
J1: MJ-352W-C; MJ-352-M-C
JP1, JP2: PINHD-1X2"; 1*02
L1: 68mH; LHL10NB104J
LEDBATTERY: LED3MM
N1: 20; 1608
N2: 20; R_0.3
N3, N4: 270; 1608
P11, P21: 270; R_0.3
P12, P22: 3.3k; R_0.3
Q1: FDS4935A
R1: RESISTORS3216; 3216
U$3: 3296W; R_VARIABLE
U$4, U$8, U$10, U$11, U$12, U$18, U$23, U$25, U$27, U$28, U$31, U$39, U$40, U$42, U$45, U$46, U$47, U$48, U$49, U$50, U$51, U$52, U$53, U$54, U$55, U$56, U$57, U$58, U$59, U$60, U$61, U$62, U$63, U$64, U$71, U$74, U$78, U$79, U$80, U$81, U$82, U$83: UT1007-Z325R
U$5: ICM7555CD; SOP8
U$14: 74HC04NS; SOP14
U$16: BF2904F; SOP8
U$29: UPA2753GR
U$35, U$36: 2SA1162
U$37, U$38: 2SC2712
U$67: BA17805FP
U$84: SLIDE_ESD175202

Connections:
+5V: C1.P$1 (1), C2.P$1 (1), C3.P$1 (1), C8.P$1 (1), C17.P$1 (1), D4.P$1 (A), DIVR1.2, R1.P$6 (2), U$5.4 (RES), U$5.8 (V+), U$16.8 (V+), U$37.C, U$38.C, U$67.OUTPUT (OUT)
+12V: C4.P$1 (1), DP1.C, DP2.C, JP1.1, JP2.1, P11.2, P21.2, Q1.1 (S2), Q1.3 (S1), U$84.A
AGND: 555C1.P$2 (2), AUC1.P$2 (2), AUR1.1, AUR2.P$1 (1), C1.P$2 (2), C8.P$2 (2), C17.P$2 (2), DIVR2.1, GC1.P$2 (2), J1.1, JP1.2, JP2.2, LEDBATTERY.K (C), P12.1, P22.1, U$5.1 (GND), U$14.1 (1A), U$14.3 (2A), U$14.5 (3A), U$14.7 (GND), U$14.9 (4A), U$16.3 (IN1+), U$16.4 (GND), U$29.1 (S1), U$29.3 (S2), U$35.C, U$36.C, U$67.COMMON (GND)
GND: C3.P$2 (2), C4.P$2 (2)
unnamed: AUR.P$1 (1), AUR2.P$2 (2), J1.2, J1.3
unnamed: AUL.P$1 (1), AUR1.2, J1.4, J1.5
unnamed: AUC1.P$1 (1), AUC2.P$1 (1), AUL.P$2 (2), AUR.P$2 (2)
unnamed: C12.1, N2.1, U$36.E, U$38.E
unnamed: BC2.P$1 (1), N4.P$1 (1), U$14.11 (5A), U$14.12 (6Y)
unnamed: Q1.7 (D22), Q1.8 (D21), U$4.2 (-), U$8.2 (-), U$10.2 (-), U$11.2 (-), U$12.2 (-), U$18.2 (-), U$23.2 (-), U$25.2 (-), U$27.2 (-), U$28.2 (-), U$29.7 (D12), U$29.8 (D11), U$31.2 (-), U$39.2 (-), U$40.2 (-), U$42.2 (-), U$45.2 (-), U$46.2 (-), U$47.2 (-), U$48.2 (-), U$49.2 (-), U$50.2 (-), U$51.2 (-), U$52.2 (-), U$53.2 (-), U$54.2 (-), U$55.2 (-), U$56.2 (-), U$57.2 (-), U$58.2 (-), U$59.2 (-), U$60.2 (-), U$61.2 (-), U$62.2 (-), U$63.2 (-), U$64.2 (-), U$71.2 (-), U$74.2 (-), U$78.2 (-), U$79.2 (-), U$80.2 (-), U$81.2 (-), U$82.2 (-), U$83.2 (-)
unnamed: 555C1.P$1 (1), 555RA1.2, U$5.2 (TRI), U$5.6 (THR)
unnamed: U$3.2, U$5.3 (OUT), U$14.13 (6A)
unnamed: 555RA1.1, U$3.1
unnamed: L1.1, Q1.5 (D12), Q1.6 (D11), U$29.5 (D22), U$29.6 (D21)
unnamed: C10.1, N1.P$1 (1), U$35.E, U$37.E
unnamed: C10.2, DP1.A, P11.1, P12.2, Q1.2 (G2)
unnamed: BC1.2, N3.P$2 (2), U$35.B, U$37.B
unnamed: BC2.P$2 (2), N4.P$2 (2), U$36.B, U$38.B
unnamed: BC1.1, N3.P$1 (1), U$14.10 (5Y)
unnamed: N1.P$2 (2), U$29.2 (G1)
unnamed: AUC2.P$2 (2), DIVR1.1, DIVR2.2, U$16.5 (IN2+)
unnamed: GC2.P$1 (1), GR1.P$2 (2), GR2.2, U$16.6 (IN2-)
unnamed: GC1.P$1 (1), GR1.P$1 (1)
unnamed: C12.2, DP2.A, P21.1, P22.2, Q1.4 (G1)
unnamed: N2.2, U$29.4 (G2)
unnamed: D4.P$2 (C), U$67.INPUT (IN), U$84.C
unnamed: U$16.1 (OUT1), U$16.2 (IN1-)
unnamed: GC2.P$2 (2), GR2.1, U$5.5 (CON), U$16.7 (OUT2)
unnamed: LEDBATTERY.A, R1.P$5 (1)
unnamed: L1.2, U$4.1 (+), U$8.1 (+), U$10.1 (+), U$11.1 (+), U$12.1 (+), U$18.1 (+), U$23.1 (+), U$25.1 (+), U$27.1 (+), U$28.1 (+), U$31.1 (+), U$39.1 (+), U$40.1 (+), U$42.1 (+), U$45.1 (+), U$46.1 (+), U$47.1 (+), U$48.1 (+), U$49.1 (+), U$50.1 (+), U$51.1 (+), U$52.1 (+), U$53.1 (+), U$54.1 (+), U$55.1 (+), U$56.1 (+), U$57.1 (+), U$58.1 (+), U$59.1 (+), U$60.1 (+), U$61.1 (+), U$62.1 (+), U$63.1 (+), U$64.1 (+), U$71.1 (+), U$74.1 (+), U$78.1 (+), U$79.1 (+), U$80.1 (+), U$81.1 (+), U$82.1 (+), U$83.1 (+)
unnamed: C2.P$2 (2), U$14.14 (V+)

Notes on the sheet:
f=1/(1.4*RC*C) RC=46kΩ C=0.000390uf f=40kHz
オペアンプ
発振回路
タイマーIC555
オーディオIN
増幅回路
降圧回路12V→5V
三端子レギュレータ
超音波発振子
出力回路
入力回路
NOT回路
スイッチング Hブリッジ回路
スピーカー
確認用LED

Board: 2 copper layers, 117.1 x 57.2 mm, 95 parts (34 on the bottom side), 31 nets.

## EAGLE design MaizuruKosen_portfolio/2017/回路設計/Gourobo2017/main_curcuit/asaMain/asaMain7_out4.brd

Parts:
AR1: ARUDUINO_MEGA_2560_R3
C1, C2, C14, C15: CAPACITOR-330U_SMD; C_330U_SMD
C3, C4, C7, C8, C12, C13: MLCC-3; MLCC_50
C5, C6: 0.1UF; MLCC_50
D1, D5: DIODE_3
D2, D3: DIODE_4
IC2: 78; 78XX
JP1, JP10, JP24: PINHD-1X2"; 1*02
JP2, JP33, JP34: PINHD-1X1; 1X01
JP3, JP26: PINHD-2X7; 2X07
JP4, JP5, JP6, JP7, JP8, JP9, JP25, JP27, JP28, JP29, JP30, JP31, JP32: PINHD-1X3-1; 1*03
JP22, JP23: PINHD-1X5-1; 1*05(KIKAKU)
LED1, LED2, LED3, LED6, LED7, LED8, LED9: LED3MM
LEDBATTERY: LED3MM_2
LEDBATTERY1: LED3MM
OK1, OK2, OK3, OK4, OK5, OK6: TLP621; DIP4
Q1, Q2: N-FET; TO-220V
R1, R16, R17, R18, R19, R21: RESISTORS3216; 3216
R2, R4: 500; R_0.3
R3, R5: 400; 3216
R6, R7: 1k; 3216
R8: 300; R_0.3
R9: 3.3k; R_0.4
R10: 12k; R_0.4
R11, R12, R13, R14, R15, R20: 300; 3216
R41: 4.7k; R_0.3
R43: 10k; R_0.3
SW1, SW2, SW3, SW5: TOGGLE; 9450-2
SW4: TACT; 1273
TR1: 1815; GSPACE
U$7, U$17: TLP251; DIP8
U$28, U$45: ASADORA2017A
U$34: NJU7223FXX
XB1: XBEE-; XBEE-MAIN

Connections:
3.3OUT: C13.1, C15.PLUS (1), D5.A, R41.2, U$34.P$1 (OUT), XB1.1 (VCC)
+5V: AR1.5V@2 (5VOUT1), C2.PLUS (1), C4.1, C7.1, C12.1, C14.PLUS (1), D1.A, D5.C, IC2.P$3 (OUT), JP3.7, JP10.1, JP22.2, JP23.2, R1.P$6 (2), R43.2, U$28.5V, U$34.P$2 (IN), U$45.5V
+12V: C5.2, C6.2, D2.C, D3.C, JP34.1, U$7.8, U$17.8, U$28.12V, U$45.12V
-10V: C8.2, JP4.3 (1), JP5.3 (1), JP6.3 (1), JP7.3 (1), JP8.3 (1), JP9.3 (1), JP24.2, LEDBATTERY1.K (C)
DB4: AR1.40 ((RD)PG1), JP26.8
DB5: AR1.38 ((T0)PD7), JP26.10
DB6: AR1.36 ((A9)PC1), JP26.12
DB7: AR1.34 ((A11)PC3), JP26.14
DENJI1: AR1.33 ((A12)PC4), R3.P$5 (1), R7.P$5 (1)
DENJI2: AR1.31 ((A14)PC6), R5.P$5 (1), R6.P$5 (1)
E: AR1.42 (PL7), JP26.6
EN1A: AR1.18 ((TXD1/INT3)PD3), JP22.3
EN1B: AR1.19 ((RXD1/INT2)PD2), JP22.4
EN2A: AR1.20 ((SDA/INT1)PD1), JP23.3
EN2B: AR1.21 ((SCL/INT0)PD0), JP23.4
FOT1: AR1.A0 ((ADC0)PF0), JP3.10
FOT2: AR1.A1 ((ADC1)PF1), JP3.8
FOT3: AR1.A2 ((ADC2)PF2), JP3.6
FOT4: AR1.A3 ((ADC3)PF3), JP3.4
GND: AR1.GND@1 (GND), AR1.GND@3 (GND), AR1.GND@5 (GND), C1.MINUS (2), C2.MINUS (2), C3.2, C4.2, C7.2, C12.2, C13.2, C14.MINUS (2), C15.MINUS (2), IC2.P$2 (GND), JP1.2, JP3.12, JP10.2, JP22.1, JP23.1, LED1.K (C), LED2.K (C), LED6.K (C), LED7.K (C), LED8.K (C), LED9.K (C), LEDBATTERY.K (C), OK1.2 (C), OK2.2 (C), OK3.2 (C), OK4.2 (C), OK5.2 (C), OK6.2 (C), R8.1, R10.1, SW2.2, SW3.2, SW4.3 (S), SW4.4 (S1), U$7.3, U$7.4, U$17.3, U$17.4, U$28.GND, U$34.P$3 (GND), U$45.GND, XB1.10 (GND)
GND12: C5.1, C6.1, Q1.3 (S), Q2.3 (S), U$7.5, U$17.5, U$28.MGND1, U$28.MGND2, U$45.MGND1, U$45.MGND2
LED1: AR1.A11 (PK3(ADC11/PCINT19)), R19.P$6 (2)
LED2: AR1.A12 (PK4(ADC12/PCINT20)), R18.P$6 (2)
LED3: AR1.A13 (PK5(ADC13/PCINT21)), R17.P$6 (2)
LED4: AR1.A14 (PK6(ADC14/PCINT22)), R16.P$6 (2)
MO1A: AR1.11 ((OC1A/PCINT5)PB5), JP25.3 (1)
MO1B: AR1.13 ((OC0A/OC1C/PCINT7)PB7), JP25.1 (3)
MO1P: AR1.12 ((OC1B/PCINT6)PB6), JP25.2
MO2A: AR1.8 (PH5(OC4C)), JP27.1 (3)
MO2B: AR1.10 ((OC2A/PCINT4)PB4), JP27.3 (1)
MO2P: AR1.9 (PH6(OC2B)), JP27.2
MO3A: AR1.7 (PH4(OC4B)), JP28.1 (3)
MO3B: AR1.1 ((TXD0)PE1), JP28.3 (1)
MO3P: AR1.6 (PH3(OC4A)), JP28.2
MO4A: AR1.27 ((AD5)PA5), JP29.1 (3)
MO4B: AR1.29 ((AD7)PA7), JP29.3 (1)
MO4P: AR1.5 ((OC3A/AIN1)PE3), JP29.2
MO5A: AR1.15 (PJ0(RXD3/PCINT9)), JP30.1 (3)
MO5B: AR1.14 (PJ1(TXD3/PCINT10)), JP30.3 (1)
MO5P: AR1.4 ((OC0B)PG5), JP30.2
MO6A: AR1.22 ((AD0)PA0), JP31.1 (3)
MO6B: AR1.24 ((AD2)PA2), JP31.3 (1)
MO6P: AR1.3 ((OC3C/INT5)PE5), JP31.2
MO7A: AR1.23 ((AD1)PA1), JP32.1 (3)
MO7B: AR1.25 ((AD3)PA3), JP32.3 (1)
MO7P: AR1.2 ((OC3B/INT4)PE4), JP32.2
unnamed: LED9.A, R19.P$5 (1)
unnamed: LED8.A, R18.P$5 (1)
unnamed: OK1.1 (A), R11.P$6 (2)
unnamed: JP1.1, SW1.1 (O)
unnamed: C1.PLUS (1), C3.1, D1.C, IC2.P$1 (IN), SW1.2
unnamed: Q1.1 (G), R2.2
unnamed: Q2.1 (G), R4.2
unnamed: LED7.A, R17.P$5 (1)
unnamed: R3.P$6 (2), U$7.2
unnamed: R2.1, U$7.6
unnamed: OK2.1 (A), R12.P$6 (2)
unnamed: LED1.A, R7.P$6 (2)
unnamed: R4.1, U$17.6
unnamed: LEDBATTERY1.A, R21.P$5 (1)
unnamed: LED6.A, R16.P$5 (1)
unnamed: LED2.A, R6.P$6 (2)
unnamed: R5.P$6 (2), U$17.2
unnamed: D2.A, JP2.1, Q2.2 (D)
unnamed: JP7.1 (3), OK3.3 (EMIT)
unnamed: JP8.1 (3), OK5.3 (EMIT)
unnamed: JP4.1 (3), OK1.3 (EMIT)
unnamed: OK3.1 (A), R13.P$6 (2)
unnamed: JP5.1 (3), OK2.3 (EMIT)
unnamed: OK5.1 (A), R15.P$6 (2)
unnamed: JP9.1 (3), OK6.3 (EMIT)
unnamed: OK6.1 (A), R20.P$6 (2)
unnamed: JP6.1 (3), OK4.3 (EMIT)
unnamed: OK4.1 (A), R14.P$6 (2)
unnamed: D3.A, JP33.1, Q1.2 (D)
unnamed: LEDBATTERY.A, R1.P$5 (1)
unnamed: LED3.A, XB1.18 (ON/SLEEP)
unnamed: LED3.K (C), R8.2
unnamed: C8.1, JP4.2, JP5.2, JP6.2, JP7.2, JP8.2, JP9.2, OK1.4 (COL), OK2.4 (COL), OK3.4 (COL), OK4.4 (COL), OK5.4 (COL), OK6.4 (COL), R21.P$6 (2), SW5.2
unnamed: R9.2, R10.2, XB1.3 (DIN/CONFIGIG)
unnamed: JP24.1, SW5.1 (O)
unnamed: R41.1, TR1.B
unnamed: TR1.E, XB1.2 (DOUT)
RIMIT1: AR1.A4 ((ADC4/TCK)PF4), JP3.2
RIMIT2: AR1.A5 ((ADC5/TMS)PF5), JP3.1
RIMIT3: AR1.A6 ((ADC6/TDO)PF6), JP3.3
RIMIT4: AR1.A7 ((ADC7/TDI)PF7), JP3.5
RIMIT5: AR1.46 (PL3(OC5A)), JP3.9
RIMIT6: AR1.48 (PL1(ICP5)), JP3.11
RIMIT7: AR1.50 ((MISO/PCINT3)PB3), JP3.13
RIMIT8: AR1.52 ((SCK/PCINT1)PB1), JP3.14
RS: AR1.44 (PL5(OC5C)), JP26.4
RXD: AR1.17 (PH0(RXD2)), R43.1, TR1.C
SERVO1: AR1.53 ((SS/PCINT0)PB0), R11.P$5 (1)
SERVO2: AR1.51 ((MOSI/PCINT2)PB2), R12.P$5 (1)
SERVO3: AR1.49 (PL0(ICP4)), R13.P$5 (1)
SERVO4: AR1.47 (PL2(T5)), R14.P$5 (1)
SERVO5: AR1.45 (PL4(OC5B)), R15.P$5 (1)
SERVO6: AR1.43 (PL6), R20.P$5 (1)
TACT1: AR1.A9 (PK1(ADC9/PCINT17)), SW4.1, SW4.2 (P1)
TOGLE1: AR1.A8 (PK0(ADC8/PCINT16)), SW3.1 (O)
TOGLE2: AR1.A10 (PK2(ADC10/PCINT18)), SW2.1 (O)
TXD: AR1.16 (PH1(TXD2)), R9.1

Notes on the sheet:
Signal LED
エンコーダー
シリンダー駆動
信号線
5V⇔3.3V変換
LCD
サーボ回路

Board: 2 copper layers, 188.0 x 143.0 mm, 93 parts (21 on the bottom side), 103 nets.

## Commit log

2018-07-08 Add files via upload
    firstCommit
2018-07-08 Add files via upload
    AddFile 夢パシャ製作記.txt
2018-07-08 firstTest remoteTest
2018-07-08 add info
2018-07-09 commit test
2018-07-10 addFile 2015ARVR
2018-07-10 addfile
2018-07-10 update 内容追記
    今後学習する言語を付け加えた
2018-07-10 add ポートフォリオ2018
    WEBと創造工学ファイルを追加
2018-07-10 add ポートフォリオ2017追加
2018-07-10 add ポートフォリオ2016
    ２Sトレースカー
2018-07-10 add ポートフォリオ2016
    2016回路設計
2018-07-10 add ポートフォリオ2016
    2016機械設計輪投げくん
2018-07-10 update README.md
    gitではファイルが壊れていて閲覧できないため、GoogleDriveのリンクを追加した
2018-07-11 upgrade 夢パシャ製作記.txt
    実体験追加
2018-07-12 upgrade README.md
    製作中のWEBサイト「夢パシャ」を無料サーバーに移行することで公開可能になった。
